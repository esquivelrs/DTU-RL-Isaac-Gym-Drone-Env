Commit message: drone passing the hoops

File: assets/urdf/Drone.urdf (robot description, URDF)
Before this commit: robot quadrotor, 5 links, 4 joints
Links:
- link base_link: geometry collision cylinder length=0.04 radius=0.2; visual cylinder length=0.025 radius=0.1
